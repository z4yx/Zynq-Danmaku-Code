SRC_URI += "file://user_2017-02-24-13-31-00.cfg;subdir=git \
            file://user_2017-02-24-14-05-00.cfg;subdir=git \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

